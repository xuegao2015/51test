# Keil uVision project ZYWIFI0939C超声波避障程序（1602显示距离）.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: ZYWIFI0939C超声波避障程序（1602显示距离） +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源代码组 1
    ./: main.c
